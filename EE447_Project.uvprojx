# Keil uVision project EE447_Project.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EE447_Project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: DELAY100.s MAIN.s Startup.s INIT_GPIO.s INIT_ADC.s My_GPIO_PORTF_Handler.s FullStepMode.s MEASURE_PULSE_WIDTH.s MY_MOTOR_Handler.s PWM_AND_MOTOR_INIT.s CONVERT_PRINT.s BAR_SELECTION.s NOKIA_5110_LCD.s ADC_THRESHOLD.s SCREEN_OUTPUTS.s
